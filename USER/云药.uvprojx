# Keil uVision project 云药.uvprojx, settings and files
target 云药 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 云药 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\TIMER;..\HARDWARE\DHT11;..\HARDWARE\ADC;..\HARDWARE\MQ_2;..\HARDWARE\USART3;..\HARDWARE\Gizwits;..\HARDWARE\LED;..\HARDWARE\LED;..\commmand包\MCU_Common_source;..\HARDWARE\KEY;..\commmand包\MCU_Common_source\Utils;..\commmand包\Utils;..\commmand包\MCU_Common_source\Gizwits
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MQ_2/: MQ_2.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_adc.c
  group README
    ../: README.TXT
  group USART3
    ../HARDWARE/USART3/: usart3.c
  group Gizwits
    ../HARDWARE/Gizwits/: gizwits_product.c gizwits_protocol.c
  group Command
    ../commmand包/Utils/: common.c dataPointTools.c ringbuffer.c
